PILHA   SEGMENT STACK
	DB 32 DUP ('STACK---')
PILHA   ENDS

DADOS   SEGMENT
	MENSAGEM DB 'Hello World!', 0DH, 0AH
	TAMANHO EQU $-MENSAGEM
	CONTADOR DB ?
DADOS   ENDS

CODIGO  SEGMENT
	ASSUME CS: CODIGO, SS: PILHA, DS: DADOS
	START:  MOV AX, DADOS    ; Inicializa segmento de dados
		MOV DS, AX
		MOV CONTADOR, 10
		
	DE_NOVO: 
		CALL FRASE
		DEC CONTADOR
		JNZ DE_NOVO
		MOV AH, 4CH ; Retorna ao DOS
		INT 21H
	
	FRASE   PROC NEAR
		MOV BX, 0001H
		LEA DX, MENSAGEM
		MOV CX, TAMANHO
		MOV AH, 40H
		INT 21H     ; Escreve mensagem
		RET
	FRASE   ENDP
CODIGO  ENDS
	END START
